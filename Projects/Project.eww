<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>fenjiuji_boot</name>
      <member>
        <project>Project</project>
        <configuration>STM3210C_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


