# IAR project Project.ewp, settings and files
configuration APP (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE; MAKE_APP
  ICCARM.CCIncludePath2: ..\App\Inc; ..\Drivers\BSP\Inc; ..\Drivers\CMSIS\Include; ..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\FreeRTOS\Source\CMSIS_RTOS; ..\FreeRTOS\Source\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\App\Inc; ..\Drivers\BSP\Inc; ..\Drivers\CMSIS\Device\Include; ..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\FreeRTOS\Source\CMSIS_RTOS; ..\FreeRTOS\Source\include
  OBJCOPY.OOCOutputFile: ProjectApp.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: ..\Drivers\CMSIS\linker\stm32f103xe_flash_app.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration BOOT (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE; MAKE_BOOT
  OBJCOPY.OOCOutputFile: ProjectBoot.bin
  ILINK.IlinkIcfFile: ..\Drivers\CMSIS\linker\stm32f103xe_flash_boot.icf
  group app
    ../App/Src/: boot.c daemon.c divid_cap.c lib.c main.c rtc.c shell_cmd.c store.c store_file.c store_param.c task_ethernet.c task_lcd.c task_rtu.c task_shell.c task_wifi.c temp_ctrl.c upgrade.c ymodem.c
  group drivers
    ../Drivers/BSP/Src/: bsp.c bsp_adc.c bsp_sdcard.c bsp_uart.c esp8266.c flash_if.c stm32f1xx_hal_msp.c stm32f1xx_it.c w25q64.c W5500.c
  group drivers/CMSIS
    ../Drivers/CMSIS/Device/: startup_stm32f103xe.s system_stm32f1xx.c
    ../Drivers/CMSIS/linker/: stm32f103xe_flash_app.icf stm32f103xe_flash_boot.icf
  group drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_sdmmc.c
  group freertos
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group freertos/CMSIS_RTOS
    ../FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group freertos/portable
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
